# Repository 2k2e2n/macro-keyboard

File readme.md:

# Macro-Keyboard

完全自作マクロキーボード

---

## Features

* 基板からケースまで完全自作
* webページからキー割り当てを変更可能
* MXcherry hotswapに対応
* ロータリーエンコーダを搭載

## Firmware

[https://2k2e2n.github.io/macro-keyboard/config/](https://2k2e2n.github.io/macro-keyboard/config/)
👆にアクセスして書き換え

もしくは```dist/config/index.html```を開く

## Sales page
作成中

## KiCad design PCB/macro-keyboard.kicad_pcb

Parts:
C1, C2, C3, C4: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D2, D3, D4, D5, D6, D7, D8, D9: D; D_DO-35_SOD27_P7.62mm_Horizontal
H1, H2, H3, H4, H5: MountingHole; MountingHole_3.2mm_M3
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
R3, R4: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R6: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: DFU-mode; SW_SPST_EVQP0
SW2: RotaryEncoder; RotaryEncoder_Alps_EC12E_Vertical_H20mm
SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10: keySW; SW_Hotswap_Kailh_MX_Plated_1.00u
SW11: debug-SW; SW_SPST_EVQP0
U1: CH552T; TSSOP-20_4.4x6.5mm_P0.65mm; MANUFACTURER PART CH552T; LCSC PART NAME 8位增强型USB单片机

Connections:
+3V3: C1.1, C3.1, SW1.2, U1.20 (V33)
+5V: C2.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), R4.2, U1.19 (VCC/VDD); also elsewhere on the board
/Col0: SW3.2, SW7.2, U1.4 (P1.6/MISO/RXD1/TIN4)
/Col1: SW4.2, SW8.2, U1.5 (P1.7/SCK/TXD1/TIN5)
/Col2: SW5.2, SW9.2, U1.6 (RST/T2EX_/CAP2_)
/Col3: SW6.2, SW10.2, U1.7 (P1.0/T2/CAP1/TIN0)
/D+: J1.A6 (D+), J1.B6 (D+), R3.2, U1.14 (P3.6/UDP)
/D-: J1.A7 (D-), J1.B7 (D-), U1.15 (P3.7/UDM)
/LED: U1.9 (P3.1/PWM2_/TXD); also elsewhere on the board
/Row0: D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), U1.12 (P3.4/PWM2/RXD1_/T0)
/Row1: D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), U1.11 (P3.3/INT1)
/debug: C4.2, R4.1, SW11.2, U1.10 (P3.0/PWM1_/RXD)
/rotary-A: SW2.A, U1.2 (P1.4/T2_/CAP1_/SCS/TIN2/UCC1/AIN1)
/rotary-B: SW2.B, U1.3 (P1.5/MOSI/PWM1/TIN3/UCC2/AIN2)
GND: C1.2, C2.2, C4.1, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.SH (SHIELD), R5.2, R6.2, SW2.C, SW11.1, U1.18 (GND/VSS); also elsewhere on the board
unnamed: C3.2, R3.1, SW1.1
unnamed: D2.2 (A), SW3.1
unnamed: D3.2 (A), SW4.1
unnamed: D4.2 (A), SW5.1
unnamed: D5.2 (A), SW6.1
unnamed: D6.2 (A), SW7.1
unnamed: D7.2 (A), SW8.1
unnamed: D8.2 (A), SW9.1
unnamed: D9.2 (A), SW10.1
unnamed: J1.A5 (CC1), R6.1
unnamed: J1.B5 (CC2), R5.1

Notes on the sheet:
keyswitch
Hole
LED
MCU
rotary-encoder
debug
USB-C

Parts:
C5: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6: 3.9u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D11, D12, D13, D14, D15, D16, D17, D18, D19: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm

Connections:
+5V: C5.1, C6.1, D11.1 (VDD), D12.1 (VDD), D13.1 (VDD), D14.1 (VDD), D15.1 (VDD), D16.1 (VDD), D17.1 (VDD), D18.1 (VDD), D19.1 (VDD); also elsewhere on the board
/LED: D11.4 (DIN); also elsewhere on the board
GND: C5.2, C6.2, D11.3 (VSS), D12.3 (VSS), D13.3 (VSS), D14.3 (VSS), D15.3 (VSS), D16.3 (VSS), D17.3 (VSS), D18.3 (VSS), D19.3 (VSS); also elsewhere on the board
unnamed: D11.2 (DOUT), D12.4 (DIN)
unnamed: D12.2 (DOUT), D13.4 (DIN)
unnamed: D13.2 (DOUT), D14.4 (DIN)
unnamed: D14.2 (DOUT), D15.4 (DIN)
unnamed: D15.2 (DOUT), D16.4 (DIN)
unnamed: D16.2 (DOUT), D17.4 (DIN)
unnamed: D17.2 (DOUT), D18.4 (DIN)
unnamed: D18.2 (DOUT), D19.4 (DIN)

Notes on the sheet:
使用するのはOSTW3535C1A

Board: 2 copper layers, 100.0 x 40.0 mm, 46 parts (24 on the bottom side), 34 nets.

Other parts of the board:
QR*****: qrcode

## Commit log (part)

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2026-05-13 回路図完成
2026-05-13 PCB作成
2026-05-14 PCB作成（続き）
2026-05-15 ケース設計
2026-05-18 ケース作成
2026-06-10 ソフトウェアを作成
2026-06-12 ホームページ作成
